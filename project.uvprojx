# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L010RBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __STDC_LIMIT_MACROS, STM32L053xx, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, USE_HAL_DRIVER, RT_USING_ARM_LIBC
  c include: applications;.;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m0;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;libraries\HAL_Drivers;libraries\HAL_Drivers\config;libraries\HAL_Drivers\CMSIS\Include;rt-thread\components\finsh;packages\ina260-latest;.;rt-thread\include;libraries\STM32L0xx_HAL\STM32L0xx_HAL_Driver\Inc;libraries\STM32L0xx_HAL\CMSIS\Device\ST\STM32L0xx\Include;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\sensors;rt-thread\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x800
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: stdlib.c time.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/CubeMX_Config/Src/: stm32l0xx_hal_msp.c
    board/: board.c
    libraries/STM32L0xx_HAL/CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l053xx.s
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group ina260
    packages/ina260-latest/: example_ina260.c sensor_ti_ina260.c ina260.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    libraries/STM32L0xx_HAL/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_pwr.c stm32l0xx_hal_crc.c stm32l0xx_hal.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_rng.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_usart.c stm32l0xx_hal_cortex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_cryp_ex.c
    libraries/STM32L0xx_HAL/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Sensors
    rt-thread/components/drivers/sensors/: sensor_cmd.c sensor.c
